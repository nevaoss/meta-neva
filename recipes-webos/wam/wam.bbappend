# Copyright 2019 LG Electronics, Inc.

require wam-neva.inc

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# Add required patches for WAM here.
SRC_URI += " \
"
