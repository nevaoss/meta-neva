# Copyright 2018 LG Electronics, Inc.

require webruntime-neva.inc
require webruntime-siso.inc
