# Copyright 2025 LG Electronics, Inc.

require webruntime-neva.inc
require webruntime-siso.inc
