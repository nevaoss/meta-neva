# Copyright 2023 LG Electronics, Inc.

EXTENDPRAUTO:append = "neva1"

FILESEXTRAPATHS:prepend := "${THISDIR}:"

SRC_URI += "file://0001-build-webos-Allow-connman-to-control-NFS-root-device.patch"
