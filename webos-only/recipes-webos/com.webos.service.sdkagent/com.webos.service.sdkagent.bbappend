# com.webos.service.sdkagent=3
# http://gpro.lge.com/c/webos-pro/meta-lg-webos/+/345328

# The bug fix change belongs to com.webos.service.sdkagent=3
# http://gpro.lge.com/c/webosose/com.webos.service.sdkagent/+/345319

# Note: This change is not necessary for the next platform upgrade (RP#2320) of NEVA.

WEBOS_VERSION = "1.0.0-3_9d310af3007d0ac5d9d005709c211611222d9024"