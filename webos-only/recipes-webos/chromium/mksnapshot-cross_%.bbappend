# Copyright 2021 LG Electronics, Inc.

require webruntime-common-ose.inc
