# Copyright 2025 LG Electronics, Inc.

require webruntime-ose.inc
