# Copyright 2018 LG Electronics, Inc.

require webruntime-ose.inc
